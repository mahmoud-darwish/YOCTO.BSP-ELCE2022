COMPATIBLE_MACHINE = "wb15"
