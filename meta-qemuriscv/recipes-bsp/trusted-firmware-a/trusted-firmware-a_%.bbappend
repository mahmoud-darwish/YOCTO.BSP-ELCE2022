COMPATIBLE_MACHINE = "wb15"
TFA_PLATFORM = "imx8mm"
TFA_BUILD_TARGET = "bl31"
